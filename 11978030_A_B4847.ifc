Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 50873fa0-dea5-416d-a26b-c46dc11760b2, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-15T10:15:44+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11978030_A_B4847:13484721_A_11978030_B4847, (2)
In: Default
Type - Material: SAN Plastic, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Dampf, z_Miele_Design_BRWS, z_Miele_Design_Cast, z_Miele_Design_CLST, z_Miele_Design_Alusilver, z_Miele_Connection_Electric, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 470 mm; Height: 970 mm; Depth: 1480 mm
Classification: E1010620 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 13484721_A_11978030_B4847; sets with these values: 2

# IfcDistributionPort, Port_355183_1
Description: Flow; FlowDirection: SOURCEANDSINK
